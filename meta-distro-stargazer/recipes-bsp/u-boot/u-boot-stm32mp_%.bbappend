FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI +="file://0001-Stargazer-OS-U-boot-development-enablement.patch"

