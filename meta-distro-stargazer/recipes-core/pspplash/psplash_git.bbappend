FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"


SPLASH_IMAGES = "file://psplash-poky-img.h;outsuffix=default"